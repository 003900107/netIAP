# Keil uVision project Project.uvproj, settings and files
target STM3210C-EVAL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c misc: --diag_suppress 3017
  c include: ..\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_ETH_Driver\inc;..\..\..\Utilities\Third_Party\lwip_v1.3.1\port\STM32;..\..\..\Utilities\Third_Party\lwip_v1.3.1\src\include;..\..\..\Utilities\Third_Party\lwip_v1.3.1\src\include\ipv4;..\..\..\Utilities\Third_Party\lwip_v1.3.1\src\include\lwip;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Utilities\Third_Party\lwip_v1.3.1\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../src/: flash_if.c httpserver.c main.c netconf.c stm32f10x_it.c stm32f107.c tftpserver.c
  group STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_flash.c misc.c stm32f10x_adc.c stm32f10x_i2c.c stm32f10x_wwdg.c stm32f10x_dma.c
  group STM32_ETH_Driver
    ../../../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_ioe.c stm3210c_eval_lcd.c
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group LwIP
    ../../../Utilities/Third_Party/lwip_v1.3.1/port/STM32/: ethernetif.c
    ../../../Utilities/Third_Party/lwip_v1.3.1/src/api/: tcpip.c api_lib.c netbuf.c netifapi.c netdb.c api_msg.c err.c
    ../../../Utilities/Third_Party/lwip_v1.3.1/src/core/: stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c init.c mem.c memp.c netif.c pbuf.c raw.c
    ../../../Utilities/Third_Party/lwip_v1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../Utilities/Third_Party/lwip_v1.3.1/src/netif/: etharp.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
